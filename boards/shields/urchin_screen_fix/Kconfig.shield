## boards/shields/urchin_screen_fix/Kconfig.shield
```kconfig
config SHIELD_URCHIN_SCREEN_FIX
    def_bool $(shields_list_contains,urchin_screen_fix)
```
